# Autodesk Inventor assembly: 21.1099_1 HANDLE 90 GRAY
## iProperties
Created: 2007-02
Part Number: 21.1099_1 HANDLE 90 GRAY
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
